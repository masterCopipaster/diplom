<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>my_transmitter</value></param>
<param><key>author</key><value>Leha</value></param>
<param><key>description</key><value>my bpsk transmitter</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>my_transmitter</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>constel</value></param>
<param><key>const_points</key><value>digital.psk_2()[0]</value></param>
<param><key>type</key><value>bpsk</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>digital.psk_2()[1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_relation</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>input_filter_freq</value></param>
<param><key>value</key><value>symb_rate * freq_relation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_0</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>samp_rate / symb_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symb_rate</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>digital_constellation_modulator</key>
<param><key>id</key><value>digital_constellation_modulator_0</value></param>
<param><key>constellation</key><value>constel</value></param>
<param><key>differential</key><value>False</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>from gnuradio import digital</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>input_filter_freq</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>input_filter_freq / 2</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<connection><source_block_id>blocks_unpack_k_bits_bb_0</source_block_id><sink_block_id>digital_constellation_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_modulator_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_modulator_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>digital_constellation_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
