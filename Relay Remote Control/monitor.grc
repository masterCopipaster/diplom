<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>bandwidth</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>5000</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>Bandwidth</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>434000000</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>Freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>offset</value></param>
<param><key>value</key><value>500000</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>label</key><value></value></param>
<param><key>true</key><value>14</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_samp_rate</value></param>
<param><key>value</key><value>2048000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>squelch_alpha</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0.5</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>1</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>squelch_db</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>-100</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>-100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>rate</key><value>1e-4</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_pll_carriertracking_cc</key>
<param><key>id</key><value>analog_pll_carriertracking_cc_0</value></param>
<param><key>w</key><value>0.06</value></param>
<param><key>max_freq</key><value>0.06</value></param>
<param><key>min_freq</key><value>-0.06</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>offset</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>rf_samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>analog_simple_squelch_cc</key>
<param><key>id</key><value>analog_simple_squelch_cc_0</value></param>
<param><key>alpha</key><value>squelch_alpha</value></param>
<param><key>threshold</key><value>squelch_db</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>1.5</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>0.5</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>epy_module_0</value></param>
<param><key>source_code</key><value># this module will be imported in the into your flowgraph&#13;
from math import pi&#13;
</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>bandwidth</value></param>
<param><key>decim</key><value>rf_samp_rate/samp_rate</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>dc_offset_mode0</key><value>1</value></param>
<param><key>freq0</key><value>freq - offset</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>40</value></param>
<param><key>iq_balance_mode0</key><value>1</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value>hackrf=2e12c3</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>rf_samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>remote_basic_decoder</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """aliexpress relay remote control PWM decoder"""

    def __init__(self, packet_separator = 10, glitch_max_width = 1, packet_length = 24):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='remote_basic_decoder',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[]#np.int32]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.packet_separator = packet_separator
        self.glitch_max_width = glitch_max_width
        self.packet_length = packet_length
        
        self.cur_state = False
        self.sample_counter = 0
        self.posedge_counter = 0
        self.negedge_counter = 0

        self.bit_index = 0
        self.result = 0

    def work(self, input_items, output_items):
    
        tobit = lambda s: True if s &gt; 0.5 else False
        
        highper = self.negedge_counter - self.posedge_counter
        lowper = self.sample_counter - self.negedge_counter
        out = []
        
        for sample in input_items[0]:
            
            
            bit = tobit(sample)
            lowper = self.sample_counter - self.negedge_counter     
            
            if lowper &gt; self.packet_separator and self.bit_index != 0:
                if self.packet_length == self.bit_index:
                    print(format(self.result, "X"))
                #out.append(np.int32(self.result))
                self.bit_index = 0
                self.result = 0
                
            if bit and not self.cur_state:
                if self.sample_counter - self.negedge_counter &gt; self.glitch_max_width :
                    highper = self.negedge_counter - self.posedge_counter
                    res = highper &gt; lowper
                    
                    if lowper &lt; self.packet_separator:
                        self.result = (self.result &lt;&lt; 1) | res
                        self.bit_index += 1
                    
                    self.posedge_counter_buffer = self.posedge_counter
                    self.posedge_counter = self.sample_counter
                else:
                    self.negedge_counter = self.negedge_counter_buffer
                
            if (not bit) and self.cur_state:
                if self.sample_counter - self.posedge_counter &gt; self.glitch_max_width :
                    self.negedge_counter_buffer = self.negedge_counter
                    self.negedge_counter = self.sample_counter
                else:
                    self.posedge_counter = self.posedge_counter_buffer
                
            self.sample_counter += 1
            self.cur_state = bit
        #output_items = np.array([out])
        return len(input_items[0])



</value></param>
<param><key>glitch_max_width</key><value>4</value></param>
<param><key>packet_length</key><value>24</value></param>
<param><key>packet_separator</key><value>200</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>freq-offset</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value>"rtl=0"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>rf_samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>t_scale</key><value>0.005</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>1</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>analog_simple_squelch_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pll_carriertracking_cc_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>analog_pll_carriertracking_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>remote_basic_decoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
